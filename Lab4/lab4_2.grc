options:
  parameters:
    author: uis-e3t
    generate_options: qt_gui
    id: MdulacionPM
    output_language: python
    title: Mdulacion PM
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    orient: Qt.Horizontal
    start: '0'
    step: '0.000001'
    stop: '10'
    value: '2.2'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    orient: Qt.Horizontal
    start: '0'
    step: '0.000001'
    stop: '1'
    value: '1'
  states: {}
- name: Kp
  id: variable_qtgui_range
  parameters:
    label: Coeficiente Kp
    orient: Qt.Horizontal
    start: '0'
    step: '0.000001'
    stop: '10'
    value: '1'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia mensaje
    orient: Qt.Horizontal
    start: '1000'
    step: '100'
    stop: '20000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: EnvolventeComplejaPM_0
  id: EnvolventeComplejaPM
  parameters:
    Ac: Ac
    Kp: Kp
  states: {}
- name: Lab_3G1J1A_0
  id: Lab_3G1J1A
  parameters:
    vect: '1024'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: lab3_parte1_0
  id: lab3_parte1
  parameters:
    I_vect: '1024'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [EnvolventeComplejaPM_0, '0', blocks_complex_to_mag_0, '0']
- [EnvolventeComplejaPM_0, '0', blocks_complex_to_real_0, '0']
- [EnvolventeComplejaPM_0, '0', qtgui_freq_sink_x_0, '0']
- [EnvolventeComplejaPM_0, '0', qtgui_time_sink_x_1, '0']
- [analog_sig_source_x_0, '0', EnvolventeComplejaPM_0, '0']
- [blocks_complex_to_mag_0, '0', Lab_3G1J1A_0, '0']
- [blocks_complex_to_real_0, '0', lab3_parte1_0, '0']

metadata:
  file_format: 1
